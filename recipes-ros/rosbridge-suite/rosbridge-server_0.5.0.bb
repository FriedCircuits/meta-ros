DESCRIPTION = "A WebSocket interface to rosbridge."
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=9;endline=9;md5=d566ef916e9dedc494f5f793a6690ba5"

DEPENDS="rosbridge-library rosapi rospy python-imaging"

require rosbridge-suite.inc
