DESCRIPTION = "Provides service calls for getting ros meta-information, like list of topics, services, params, etc."
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=12;endline=12;md5=d566ef916e9dedc494f5f793a6690ba5"

DEPENDS="rosbridge-library rospy message-generation"

require rosbridge-suite.inc
