DESCRIPTION = "Server side tools for authorization and authentication of ROS clients."
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=10;endline=10;md5=d566ef916e9dedc494f5f793a6690ba5"

DEPENDS = "roscpp message-generation rostest"

require rosauth.inc
